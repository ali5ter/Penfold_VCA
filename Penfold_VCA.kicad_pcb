# Repository ali5ter/Penfold_VCA

File README.md:

> **⚠️ Archived 2025-08-25. No longer maintained.**

# Penfold_VCA
[KiCad](https://www.kicad.org/) project for the circuit and PCB of R.A. Penfolds VCA design which I adapted as a Eurorack powered module.
The original circuit is taken from [the book, "Electronic Synthesiser Construction" by R. A. Penfold](https://sdiy.info/wiki/Penfold_synthesiser), published by Babani in 1986.

I have kept to the original design as much as possible, but added power and switched INT.CV via [a Eurorack spec bus](https://doepfer.de/home_e.htm).

I have yet to manufacture and test this circuit.

## KiCad design Penfold_VCA.kicad_pcb

Parts:
C1: 1uF; CP_Radial_D5.0mm_P2.00mm
C2: 220uF; CP_Radial_D5.0mm_P2.00mm
C3, C4, C5: 10uF; CP_Radial_D5.0mm_P2.00mm
D1, D4: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Eurorack style bus; PinHeader_2x08_P2.54mm_Vertical
J3: CV In
J4: input breakout; PinHeader_1x03_P2.54mm_Vertical
J6: Output breakout; PinHeader_1x03_P2.54mm_Vertical
R1, R9: 18k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R5: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R4: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R7, R8: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: CV Int/Ext; PinHeader_1x03_P2.54mm_Vertical
U1: LM13600; DIP-16_W7.62mm_Socket_LongPads
U2: CA3140; DIP-8_W7.62mm_Socket_LongPads

Connections:
1: R1.2, U1.1
2: C1.2, J3.T, J4.3
3: C3.2, J3.T, J6.3, SW1.2 (B), U2.3 (+)
+5V: J1.5, J1.6
+12V: C5.1, D4.1 (K), R2.1, R6.2, U1.11 (V+), U2.7 (V+)
-12V: C4.2, D1.2 (A)
CV Bus: J1.3, J1.4, SW1.1 (A)
GND: C2.2, C4.1, C5.2, J1.9, J1.10, J1.11, J1.12, J1.13, J1.14, J3.G, J3.TN, J4.1, J4.2, J6.1, J6.2, R7.1, R8.1, U1.6 (V-), U2.4 (V-)
Gate Bus: J1.1, J1.2
unnamed: C1.1, R5.1
unnamed: C2.1, R3.1, R4.1, R6.1, R7.2, R9.1
unnamed: C3.1, R8.2, U1.8
unnamed: D1.1 (K), J1.15, J1.16
unnamed: D4.2 (A), J1.7, J1.8
unnamed: R9.2, U1.5, U1.7
unnamed: J3.T, SW1.3 (C)
unnamed: R4.2, R5.2, U1.3 (+)
unnamed: R3.2, U1.4 (-)
unnamed: R2.2, U1.2 (DIODE_BIAS)
unnamed: R1.1, U2.2 (-), U2.6

Notes on the sheet:
Eurorack style power (and signal) buss
Breakout for output socket
Breakout for input socket
Audio In
Audio Out
CV In
Control voltage input buffer
Voltage controlled amplifiier

Board: 2 copper layers, 74.0 x 43.0 mm, 26 parts (0 on the bottom side), 19 nets.

## Commit log

2023-07-05 before manufacture
2023-07-06 cleanup
2023-07-23 add missing res and fix silkscreen
2023-07-23 forgot to save
2023-07-23 update version
2025-08-21 docs: sync archive banner
